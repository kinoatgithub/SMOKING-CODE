# IAR project SMOKING.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: STM8S_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: SMOKING.s19
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDataModel: 1
  ICCSTM8.CCDefines: NDEBUG
  group STD_LIB
    STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_clk.c stm8s_flash.c stm8s_itc.c stm8s_tim1.c stm8s_tim2.c
    $EW_DIR$/STM8S_StdPeriph_Libraries/STM8S_StdPeriph_Driver/src/: stm8s_gpio.c
  group USER_CODE
    USER_CODE/: main.c USER_ADC.c USER_FLASH.c USER_GPIO.c USER_HEATER.c USER_LED.c USER_TIMER.c
